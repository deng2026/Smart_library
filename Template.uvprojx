# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\beep;.\rtthread\3.0.3\bsp;.\rtthread\3.0.3\components\finsh;.\rtthread\3.0.3\include;.\rtthread\3.0.3\include\libc;.\APP\tftlcd;.\APP\menu_list;.\APP\24Cxx;.\APP\iic;.\APP\touch;.\APP\lsens;.\APP\adc_temp;.\APP\ds18b20;.\APP\dma;.\GUI;.\Others
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/key/: key.c
    ./APP/exti/: exti.c
    ./APP/beep/: beep.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/menu_list/: menu.c
    ./APP/touch/: cst716.c ctiic.c gt5663.c touch.c
    ./APP/time/: time.c
    ./APP/24Cxx/: 24cxx.c
    ./APP/iic/: iic.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group RTT_Config
    ./rtthread/3.0.3/bsp/: board.c rtconfig.h
  group RTT_Core
    ./rtthread/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group RTT_Port
    ./rtthread/3.0.3/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Others
    ./Others/: malloc.c diy_gui.c logo.h book.c keyboard.c rc522.c
